# Keil uVision project 火箭-01.uvprojx, settings and files
target 火箭-01 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0xC000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M3") CLOCK(8000000) ELITTLE
  output: rocket_01
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_HD
  c include: .\Library;.\User;.\System;.\Hardware;.\Hardware\LSM6DSV16X;.\Start
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Library
    ./Library/: misc.c misc.h stm32f10x_gpio.c stm32f10x_gpio.h stm32f10x_rcc.c stm32f10x_rcc.h stm32f10x_tim.c stm32f10x_tim.h stm32f10x_spi.c stm32f10x_spi.h stm32f10x_i2c.c stm32f10x_i2c.h stm32f10x_usart.c stm32f10x_usart.h
  group Start
    ./Start/: startup_stm32f10x_hd.s core_cm3.c core_cm3.h stm32f10x.h system_stm32f10x.c system_stm32f10x.h
  group System
    ./System/: Delay.c Delay.h Timebase.c Timebase.h PID.c PID.h ControlMath.c ControlMath.h
  group User
    ./User/: main.c stm32f10x_conf.h stm32f10x_it.c stm32f10x_it.h
  group Hardware
    ./Hardware/: RocketConfig.h LaunchProtocol.c LaunchProtocol.h RemoteLaunch.c RemoteLaunch.h Buzzer.c Buzzer.h FaultLED.c FaultLED.h DebugConfig.h DebugMode.c DebugMode.h FlightLog.c FlightLog.h Ignition.c Ignition.h Servo.c Servo.h IMU.c IMU.h W25Q64.c W25Q64.h BMP280.c BMP280.h FlightControl.c FlightControl.h AltitudeControl.c AltitudeControl.h RocketState.c RocketState.h Rocket.c Rocket.h
    ./Hardware/LSM6DSV16X/: lsm6dsv16x_reg.c lsm6dsv16x_reg.h
